## meta-hello/conf/layer.conf
```bitbake
BBPATH =. ":${LAYERDIR}"
BBFILES =+ "${LAYERDIR}/*.bb"
BBFILE_COLLECTIONS += "hello"
BBFILE_PATTERN_hello := "^${LAYERDIR}/"
```
